# Keil uVision project STM32F103C8T6Template.uvprojx, settings and files
target C8T6Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103C8T6Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\src\user;..\src\CMSIS\CM3\CoreSupport;..\src\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src\STM32F10x_StdPeriph_Driver\inc;..\src\hardware
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../src/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../src/user/: stm32f10x_it.c main.c
  group StdPeriph_Driver
    ../src/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../src/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group hardware
    ../src/hardware/: rgb.c battery_ADC.c blueTooth_HC_06.c control.c HC_SR04.c OLED.c
  group SYSTEM
    ../src/user/: delay.c
